# Keil uVision project I2C_DS_Assignment_B21CS093_B21CS074.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_DS_Assignment_B21CS093_B21CS074
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: I2C_DS_Assignment_B21CS093_B21CS074.c I2C_DS_Assignment_B21CS093_B21CS074.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
